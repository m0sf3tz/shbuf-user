## Config.in
```kconfig
config BR2_PACKAGE_SHBUF_USER
    bool "shbuf_user"
    depends on BR2_LINUX_KERNEL
    help
        This is test library package for XYZ driver.
```
